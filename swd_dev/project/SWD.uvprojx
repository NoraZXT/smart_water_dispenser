# Keil uVision project SWD.uvprojx, settings and files
target SWD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CS32F103CB AutoChips
  pack: Keil.CS32F1xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SWD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\BSP\DS18B20;..\user;..\BSP\NET;..\BSP\LCD1602;..\BSP\KEY
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group LIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group NET
    ../BSP/NET/: esp8266.c MqttKit.c onenet.c base64.c hmac_sha1.c cJSON.c
  group BSP
    ../BSP/DS18B20/: DS18B20.c
    ../BSP/LCD1602/: LCD1602.c
    ../BSP/KEY/: key.c
  group USER
    ../user/: main.c delay.c usart.c
